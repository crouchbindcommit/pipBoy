# Keil uVision project PA5.uvprojx, settings and files
target PA5ESP8266 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PA5
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --std=c99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c pll.c esp8266.c LED.c ST7735.c UART.c Sound.c weather.c Timer.c RTC.c PortF.c IO.c
software components: CMSIS:CORE 5.6.0
